# Keil uVision project stm32f.uvprojx, settings and files
target Develop (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F030R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32f +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\src\stm32f.sct
  link misc: --entry=Reset_Handler
  group core
    ./src/core/: stm32f.h types.h
  group startup
    ./src/: startup_stm32f.c
  group main
    ./src/: main.c
