LR_NVM 0x08000000
{
    ES_NVM +0
    {
        *.o     (+RO)
    }
}

LR_RAM +0
{
    ES_RAM 0x20000000
    {
        *.o     (+RW, ZI)
    }
}
